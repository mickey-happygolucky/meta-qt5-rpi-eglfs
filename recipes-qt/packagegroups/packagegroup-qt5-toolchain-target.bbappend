RDEPENDS_${PN} += " \
	       opencv-apps \
	       opencv-dev \
	       opencv-dbg \
"
